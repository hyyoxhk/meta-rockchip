# SPDX-License-Identifier: MIT
#
# Copyright (C) 2023 He Yong <hyyoxhk@163.com>
#

PATCHPATH = "${CURDIR}/${BPN}"
inherit auto-patch
