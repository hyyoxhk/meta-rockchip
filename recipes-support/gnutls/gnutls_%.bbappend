PACKAGECONFIG:append:class-native = " p11-kit"
